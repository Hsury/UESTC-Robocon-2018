# Keil uVision project Robocon2018.uvprojx, settings and files
target Robocon2018 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Robocon2018 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\APP;..\HARDWARE;..\HARDWARE\CAN;..\HARDWARE\UART;..\HARDWARE\USB\STM32_USB_Device_Library\Core\inc;..\HARDWARE\USB\STM32_USB_Device_Library\Class\cdc\inc;..\HARDWARE\USB\STM32_USB_OTG_Driver\inc;..\HARDWARE\USB\VCP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group APP
    ../APP/: Protocol.c RingBuf.c Var.c Algorithm.c PID.c Move.c Tasks.c
  group HARDWARE
    ../HARDWARE/: Buzzer.c Elmo.c GyroEncoder.c RGBLED.c Probe.c Cylinder.c Cradle.c Sensor.c
  group CAN
    ../HARDWARE/CAN/: CAN.c
  group UART
    ../HARDWARE/UART/: AirUART.c CH340.c ESP8266.c
  group USB
    ../HARDWARE/USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../HARDWARE/USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../HARDWARE/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../HARDWARE/USB/VCP/: usb_bsp.c usb_irq.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_tim.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
